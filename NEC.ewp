# IAR project NEC.ewp, settings and files
configuration NEC (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030F4 ST STM32F030F4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; HSE_VALUE=8000000; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; HSI_VALUE=8000000; LSI_VALUE=40000; VDD_VALUE=3300; PREFETCH_ENABLE=1; INSTRUCTION_CACHE_ENABLE=0; DATA_CACHE_ENABLE=0; STM32F030x6
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc; ../Drivers/CMSIS/Device/ST/STM32F0xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NEC.hex
  ILINK.IlinkOutputFile: NEC.out
  ILINK.IlinkIcfFile: stm32f030x6_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DEBUG (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 0
  group Application/EWARM
    ./: startup_stm32f030x6.s
  group Application/User/Core
    ../Core/Src/: gpio.c main.c stm32f0xx_it.c tim.c usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_dma.c stm32f0xx_ll_exti.c stm32f0xx_ll_gpio.c stm32f0xx_ll_pwr.c stm32f0xx_ll_rcc.c stm32f0xx_ll_tim.c stm32f0xx_ll_usart.c stm32f0xx_ll_utils.c
